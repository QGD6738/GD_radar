# IAR project Backup of SGMW_E200P_8S003AD.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x120
  General.GenHeapSize: 0x120
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: OffHostSensor.srec
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group INC
    SRC/: Adc.h Command.h Config.h Cpu.h DetectObj.h ReadID.h Serial.h Timer.h
  group SRC
    SRC/: Adc.c Command.c Cpu.c DetectObj.c main.c ReadID.c Serial.c Speaker.c Timer.c
    ./: 修改记录.txt 说明.txt
