# IAR project SGMW_E200P_8S003AD.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x120
  General.GenHeapSize: 0x120
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SGMW_E100_PAS_ALL_V0_01_00_200424.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group INC
    SRC/: ADC.h Command.h Config.h Cpu.h DetectObj.h ReadID.h Serial.h Timer.h
  group SRC
    SRC/: Adc.c Command.c Cpu.c DetectObj.c main.c ReadID.c Serial.c Speaker.c Timer.c
    ./: SGMW_E300_8S003_V0_2.txt
