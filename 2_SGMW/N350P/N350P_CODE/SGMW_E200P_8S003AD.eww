<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SGMW_E200P_8S003AD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


